# IAR project Project.ewp, settings and files
configuration N6-DK (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_STM32N6570_DK; STM32N6570_DK_REV=STM32N6570_DK_C01; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; NUCLEO_N6_CONFIG=0
  ICCARM.CCIncludePath2: ..; ..\Core\Inc; ..\..\Common; ..\..\Drivers\CMSIS\Core\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\..\Drivers\CMSIS\Core\DSP\Include; ..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\X-CUBE-AI\App; ..\..\Drivers\BSP\Components\mx66uw1g45g; ..\..\Drivers\BSP\STM32N6570-DK; ..\..\Drivers\BSP\STM32N6xx_Nucleo; ..\X-CUBE-AI\Target; ..\X-CUBE-AI; ..\..\..\..\..\Middlewares\ST\AI\Npu\Devices\STM32N6xx; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\..\..\..\..\Middlewares\ST\AI\Misc\Inc; ..\..\..\..\..\Middlewares\ST\AI\Validation\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Middlewares\ST\AI\Lib\ABI2.1\ARMCortexM55\NetworkRuntime1100_CM55_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration N6-Nucleo (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32N657xx; USE_STM32N6xx_NUCLEO; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; NUCLEO_N6_CONFIG=1
  ICCARM.CCIncludePath2: ..; ..\Core\Inc; ..\..\Common; ..\..\Drivers\CMSIS\Core\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\..\Drivers\CMSIS\Core\DSP\Include; ..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\X-CUBE-AI\atonn; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\X-CUBE-AI\App; ..\X-CUBE-AI\Target; ..\X-CUBE-AI\; ..\..\Drivers\BSP\Components\mx25um51245g_conf; ..\..\Drivers\BSP\STM32N6xx_Nucleo; ..\..\Drivers\BSP\STM32N6570-DK; ..\..\..\..\..\Middlewares\ST\AI\Npu\Devices\STM32N6xx; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\..\..\..\..\Middlewares\ST\AI\Misc\Inc; ..\..\..\..\..\Middlewares\ST\AI\Validation\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  group Application
    ../Core/Inc/: app_config.h
    ../Core/Src/: main.c md5.c stm32n6xx_it.c system_clock_config.c
  group Common
    ../../../../../Middlewares/ST/AI/Npu/Devices/STM32N6xx/: mcu_cache.c
    ../Core/Src/: misc_toolbox.c
  group Drivers/BSP
    ../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_xspi.c
    ../../Drivers/BSP/STM32N6xx_Nucleo/: stm32n6xx_nucleo.c stm32n6xx_nucleo_xspi.c
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/aps256xx/: aps256xx.c
    ../../Drivers/BSP/Components/mx25um51245g/: mx25um51245g.c
    ../../Drivers/BSP/Components/mx66uw1g45g/: mx66uw1g45g.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/iar/: startup_stm32n657xx_fsbl.s
    ../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_uart.c stm32n6xx_hal_xspi.c
  group X-CUBE-AI/App
    ../../../../../Middlewares/ST/AI/Misc/Src/: ai_device_adaptor.c aiTestHelper.c aiTestUtility.c lc_print.c syscalls.c
    ../../../../../Middlewares/ST/AI/Validation/Src/: aiPbIO.c aiPbMemRWServices.c aiPbMgr.c aiValidation.c pb_common.c pb_decode.c pb_encode.c stm32msg.pb.c
    ../X-CUBE-AI/App/: app_x-cube-ai.c network.c network_data.c network_data_params.c
