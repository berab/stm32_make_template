# IAR project Project_s.ewp, settings and files
configuration STM32N6570-DK_Secure (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\..\App_Secure\Inc; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\CMSIS\Core\Include; ..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\Secure_nsclib; ..\..\..\Drivers\BSP\; ..\..\..\Drivers\BSP\STM32N6570-DK
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx_ROMxspi2_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP
    ../../../Drivers/BSP/Components/aps256xx/: aps256xx.c
    ../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery_xspi.c
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/iar/: startup_stm32n657xx.s
    ../../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_s.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_rtc.c stm32n6xx_hal_rtc_ex.c stm32n6xx_hal_xspi.c
  group Example
    ../../App_Secure/Src/: main.c secure_nsc.c stm32n6xx_it.c
    ../../App_Secure/Inc/: partition_stm32n657xx.h
