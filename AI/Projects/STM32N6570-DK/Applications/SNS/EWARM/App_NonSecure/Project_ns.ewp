# IAR project Project_ns.ewp, settings and files
configuration STM32N6570-DK_NonSecure (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; __TERMINAL_IO__; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; LL_ATON_DUMP_DEBUG_API; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_BARE_METAL; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_EB_DBG_INFO; NUCLEO_N6_CONFIG=0; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1
  ICCARM.CCIncludePath2: ..\..\App_NonSecure\Inc; ..\..\Secure_nsclib; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\CMSIS\Core\Include; ..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\STM32N6570-DK; ..\..\..\..\..\..\Middlewares\ST\AI\Npu\ll_aton; ..\..\..\..\..\..\Middlewares\ST\AI\Npu\Devices\STM32N6xx; ..\..\..\..\..\..\Middlewares\ST\AI\Inc; ..\..\App_NonSecure\atonn
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project_ns.bin
  ILINK.IlinkOutputFile: Project_ns.out
  ILINK.IlinkIcfFile: stm32n657xx_ROMxspi2_ns.icf
  ILINK.IlinkAdditionalLibs: ..\App_Secure\STM32N6570-DK_Secure\Exe\Project_import_lib.lib; ..\..\..\..\..\..\Middlewares\ST\AI\Lib\ABI2.1\ARMCortexM55\NetworkRuntime1100_CM55_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ATONN
    ../../../../../../Middlewares/ST/AI/Npu/ll_aton/: ll_aton.c ll_aton_cipher.c ll_aton_dbgtrc.c ll_aton_debug.c ll_aton_lib.c ll_aton_lib_sw_operators.c ll_aton_rt_main.c ll_aton_runtime.c ll_aton_util.c ll_sw_float.c ll_sw_integer.c
  group Drivers/BSP
    ../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/iar/: startup_stm32n657xx.s
    ../../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_ns.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rtc.c stm32n6xx_hal_rtc_ex.c
  group Example
    ../../App_NonSecure/Src/: main.c network.c stm32n6xx_hal_msp.c stm32n6xx_it.c
    ../../../../../../Middlewares/ST/AI/Npu/Devices/STM32N6xx/: mcu_cache.c npu_cache.c
