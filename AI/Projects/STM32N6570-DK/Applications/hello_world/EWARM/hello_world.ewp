# IAR project hello_world.ewp, settings and files
configuration N6-DK (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; LL_ATON_DUMP_DEBUG_API; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_BARE_METAL; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_EB_DBG_INFO; NUCLEO_N6_CONFIG=0; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1
  ICCARM.CCIncludePath2: ..; ..\Inc; ..\..\Common; ..\..\Drivers\CMSIS\Core\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\..\Drivers\CMSIS\Core\DSP\Include; ..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\AI\atonn; ..\..\..\..\..\Middlewares\ST\AI\Npu\ll_aton; ..\..\..\..\..\Middlewares\ST\AI\Npu\Devices\STM32N6xx; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\AI\validation; ..\..\Drivers\BSP\Components\mx66uw1g45g; ..\..\Drivers\BSP\STM32N6570-DK; ..\..\Drivers\BSP\STM32N6xx_Nucleo
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Middlewares\ST\AI\Lib\ABI2.1\ARMCortexM55\NetworkRuntime1100_CM55_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration N6-DK-STAI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..; ..\Inc; ..\..\Common; ..\..\Drivers\CMSIS\Core\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\..\Drivers\CMSIS\Core\DSP\Include; ..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\AI\atonn; ..\AI\atonn\models; ..\..\..\..\..\Middlewares\ST\AI\Npu\ll_aton; ..\..\..\..\..\Middlewares\ST\AI\Npu\Devices\STM32N6xx; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\AI\validation; ..\..\Drivers\BSP\Components\mx66uw1g45g; ..\..\Drivers\BSP\STM32N6570-DK; ..\..\Drivers\BSP\STM32N6xx_Nucleo
configuration N6-DK-RELOC (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32N657xx; LL_ATON_RT_RELOC; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; LL_ATON_DUMP_DEBUG_API; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_BARE_METAL; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_EB_DBG_INFO; NUCLEO_N6_CONFIG=0; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1
  group AI/atonn/models
    ../AI/atonn/models/: network.c stai_network.c
  group AI/atonn/runtime
    ../../../../../Middlewares/ST/AI/Npu/ll_aton/: ecloader.c ll_aton.c ll_aton_cipher.c ll_aton_dbgtrc.c ll_aton_debug.c ll_aton_lib.c ll_aton_lib_sw_operators.c ll_aton_reloc_network.c ll_aton_rt_main.c ll_aton_runtime.c ll_aton_stai_internal.c ll_aton_util.c ll_sw_float.c ll_sw_integer.c
  group Application
    ../Inc/: app_config.h
    ../Src/: main.c main_reloc.c main_stai.c md5.c stm32n6xx_it.c system_clock_config.c uart.c
  group Common
    ../../../../../Middlewares/ST/AI/Npu/Devices/STM32N6xx/: mcu_cache.c npu_cache.c
    ../Src/: misc_toolbox.c
  group Drivers/BSP
    ../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_xspi.c
    ../../Drivers/BSP/STM32N6xx_Nucleo/: stm32n6xx_nucleo.c stm32n6xx_nucleo_xspi.c
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/aps256xx/: aps256xx.c
    ../../Drivers/BSP/Components/mx25um51245g/: mx25um51245g.c
    ../../Drivers/BSP/Components/mx66uw1g45g/: mx66uw1g45g.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/iar/: startup_stm32n657xx_fsbl.s
    ../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_uart.c stm32n6xx_hal_xspi.c
