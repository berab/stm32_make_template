# IAR project Project.ewp, settings and files
configuration N6-DK (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_STM32N6570_DK; STM32N6570_DK_REV=STM32N6570_DK_C01; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; LL_ATON_DUMP_DEBUG_API; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_BARE_METAL; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_EB_DBG_INFO; NUCLEO_N6_CONFIG=0; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1
  ICCARM.CCIncludePath2: ..; ..\Core\Inc; ..\..\Common; ..\..\Drivers\CMSIS\Core\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\..\Drivers\CMSIS\Core\DSP\Include; ..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\X-CUBE-AI\atonn; ..\..\..\..\..\Middlewares\ST\AI\Npu\ll_aton; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\..\..\..\..\Middlewares\ST\usbx\common\core\inc; ..\..\..\..\..\Middlewares\ST\usbx\target; ..\..\..\..\..\Middlewares\ST\usbx\common\usbx_device_classes\inc; ..\..\..\..\..\Middlewares\ST\usbx\common\usbx_stm32_device_controllers; ..\..\..\..\..\Middlewares\ST\usbx\ports\generic/inc; ..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Core\inc; ..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Devices\STM32N6XX\inc; ..\User\USBX; ..\X-CUBE-AI\App; ..\..\Drivers\BSP\Components\mx66uw1g45g; ..\..\Drivers\BSP\STM32N6570-DK; ..\..\Drivers\BSP\STM32N6xx_Nucleo; ..\..\..\..\..\Middlewares\ST\AI\Npu\Devices\STM32N6xx; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\..\..\..\..\Middlewares\ST\AI\Misc\Inc; ..\..\..\..\..\Middlewares\ST\AI\Validation\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Middlewares\ST\AI\Lib\ABI2.1\ARMCortexM55\NetworkRuntime1100_CM55_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration N6-DK-USB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32N657xx; UX_INCLUDE_USER_DEFINE_FILE; USE_USB_CDC_CLASS=1; UX_STANDALONE; USE_STM32N6570_DK; STM32N6570_DK_REV=STM32N6570_DK_C01; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; LL_ATON_DUMP_DEBUG_API; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_BARE_METAL; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_EB_DBG_INFO; NUCLEO_N6_CONFIG=0; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1
  ICCARM.CCIncludePath2: ..; ..\Core\Inc; ..\..\Common; ..\..\Drivers\CMSIS\Core\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\..\Drivers\CMSIS\Core\DSP\Include; ..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\X-CUBE-AI\atonn; ..\..\..\..\..\Middlewares\ST\AI\Npu\ll_aton; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\..\..\..\..\Middlewares\ST\usbx\common\core\inc; ..\..\..\..\..\Middlewares\ST\usbx\target; ..\..\..\..\..\Middlewares\ST\usbx\common\usbx_device_classes\inc; ..\..\..\..\..\Middlewares\ST\usbx\common\usbx_stm32_device_controllers; ..\..\..\..\..\Middlewares\ST\usbx\ports\generic/inc; ..\User\USBX; ..\X-CUBE-AI\App; ..\..\Drivers\BSP\Components\mx66uw1g45g; ..\..\Drivers\BSP\STM32N6570-DK; ..\..\Drivers\BSP\STM32N6xx_Nucleo; ..\..\..\..\..\Middlewares\ST\AI\Npu\Devices\STM32N6xx; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\..\..\..\..\Middlewares\ST\AI\Misc\Inc; ..\..\..\..\..\Middlewares\ST\AI\Validation\Inc
configuration N6-DK - RELOC (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32N657xx; USE_STM32N6570_DK; STM32N6570_DK_REV=STM32N6570_DK_C01; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; LL_ATON_DUMP_DEBUG_API; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_BARE_METAL; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_EB_DBG_INFO; NUCLEO_N6_CONFIG=0; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1; LL_ATON_RT_RELOC; USE_RELOC_MODE=1; AI_RELOC_LOG_ENABLE=1
  ICCARM.CCIncludePath2: ..; ..\Core\Inc; ..\..\Common; ..\..\Drivers\CMSIS\Core\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\..\Drivers\CMSIS\Core\DSP\Include; ..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\X-CUBE-AI\atonn; ..\..\..\..\..\Middlewares\ST\AI\Npu\ll_aton; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\X-CUBE-AI\App; ..\..\Drivers\BSP\Components\mx66uw1g45g; ..\..\Drivers\BSP\STM32N6570-DK; ..\..\Drivers\BSP\STM32N6xx_Nucleo; ..\..\..\..\..\Middlewares\ST\AI\Npu\Devices\STM32N6xx; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\..\..\..\..\Middlewares\ST\AI\Misc\Inc; ..\..\..\..\..\Middlewares\ST\AI\Validation\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: stm32n657xx_axisram_reloc.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration N6-DK-USB - RELOC (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32N657xx; UX_INCLUDE_USER_DEFINE_FILE; USE_USB_CDC_CLASS=1; UX_STANDALONE; USE_STM32N6570_DK; STM32N6570_DK_REV=STM32N6570_DK_C01; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; LL_ATON_DUMP_DEBUG_API; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_BARE_METAL; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_EB_DBG_INFO; NUCLEO_N6_CONFIG=0; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1; LL_ATON_RT_RELOC; USE_RELOC_MODE=1; AI_RELOC_LOG_ENABLE=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: stm32n657xx_axisram_reloc.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration N6-DK-legacy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32N657xx; STM32N6XX_SI_CUT1_1; USE_STM32N6570_DK; STM32N6570_DK_REV=STM32N6570_DK_A01; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; LL_ATON_DUMP_DEBUG_API; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_BARE_METAL; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_EB_DBG_INFO; NUCLEO_N6_CONFIG=0; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: STM32N6XX_SI_CUT1_1
configuration N6-Nucleo (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32N657xx; USE_STM32N6xx_NUCLEO; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; LL_ATON_DUMP_DEBUG_API; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_BARE_METAL; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_EB_DBG_INFO; NUCLEO_N6_CONFIG=1; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1
  ICCARM.CCIncludePath2: ..; ..\Core\Inc; ..\..\Common; ..\..\Drivers\CMSIS\Core\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\..\Drivers\CMSIS\Core\DSP\Include; ..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\X-CUBE-AI\atonn; ..\..\..\..\..\Middlewares\ST\AI\Npu\ll_aton; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\..\..\..\..\Middlewares\ST\usbx\common\core\inc; ..\..\..\..\..\Middlewares\ST\usbx\target; ..\..\..\..\..\Middlewares\ST\usbx\common\usbx_device_classes\inc; ..\..\..\..\..\Middlewares\ST\usbx\common\usbx_stm32_device_controllers; ..\..\..\..\..\Middlewares\ST\usbx\ports\generic/inc; ..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Core\inc; ..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Devices\STM32N6XX\inc; ..\User\USBX; ..\X-CUBE-AI\App; ..\..\Drivers\BSP\Components\mx25um51245g_conf; ..\..\Drivers\BSP\STM32N6xx_Nucleo; ..\..\Drivers\BSP\STM32N6570-DK; ..\..\..\..\..\Middlewares\ST\AI\Npu\Devices\STM32N6xx; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\..\..\..\..\Middlewares\ST\AI\Misc\Inc; ..\..\..\..\..\Middlewares\ST\AI\Validation\Inc
  ICCARM.CCOptStrategy: 1
configuration N6-Nucleo-USB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32N657xx; UX_INCLUDE_USER_DEFINE_FILE; USE_USB_CDC_CLASS=1; UX_STANDALONE; USE_STM32N6xx_NUCLEO; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; LL_ATON_DUMP_DEBUG_API; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_BARE_METAL; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_EB_DBG_INFO; NUCLEO_N6_CONFIG=1; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1
  ICCARM.CCIncludePath2: ..; ..\Core\Inc; ..\..\Common; ..\..\Drivers\CMSIS\Core\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\..\Drivers\CMSIS\Core\DSP\Include; ..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\X-CUBE-AI\atonn; ..\..\..\..\..\Middlewares\ST\AI\Npu\ll_aton; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\..\..\..\..\Middlewares\ST\usbx\common\core\inc; ..\..\..\..\..\Middlewares\ST\usbx\target; ..\..\..\..\..\Middlewares\ST\usbx\common\usbx_device_classes\inc; ..\..\..\..\..\Middlewares\ST\usbx\common\usbx_stm32_device_controllers; ..\..\..\..\..\Middlewares\ST\usbx\ports\generic/inc; ..\User\USBX; ..\X-CUBE-AI\App; ..\..\Drivers\BSP\Components\mx25um51245g_conf; ..\..\Drivers\BSP\STM32N6xx_Nucleo; ..\..\Drivers\BSP\STM32N6570-DK; ..\..\..\..\..\Middlewares\ST\AI\Npu\Devices\STM32N6xx; ..\..\..\..\..\Middlewares\ST\AI\Inc; ..\..\..\..\..\Middlewares\ST\AI\Misc\Inc; ..\..\..\..\..\Middlewares\ST\AI\Validation\Inc
  ICCARM.CCOptStrategy: 1
configuration N6-BlowFuses (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32N657xx; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; NUCLEO_N6_CONFIG=0
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Project.srec
configuration N6-DK-STAI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32N657xx; ATON_STAI_API; USE_STM32N6570_DK; STM32N6570_DK_REV=STM32N6570_DK_C01; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; LL_ATON_DUMP_DEBUG_API; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_BARE_METAL; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_EB_DBG_INFO; NUCLEO_N6_CONFIG=0; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1
configuration N6-DK-STAI-USB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32N657xx; ATON_STAI_API; UX_INCLUDE_USER_DEFINE_FILE; USE_USB_CDC_CLASS=1; UX_STANDALONE; USE_STM32N6570_DK; STM32N6570_DK_REV=STM32N6570_DK_C01; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM; LL_ATON_DUMP_DEBUG_API; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_BARE_METAL; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_EB_DBG_INFO; NUCLEO_N6_CONFIG=0; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1
  ICCARM.CCIncludePath2: as above
  group Application
    ../Core/Inc/: app_config.h
    ../Core/Src/: main.c md5.c stm32n6xx_it.c system_clock_config.c
  group Application/Blow_Fuses
    ../X-CUBE-AI/App_fuse/: main.c
  group Application/User/USBX
    ../User/USBX/: app_usbx_device.c ux_device_cdc_acm.c ux_device_descriptors.c
  group Common
    ../../../../../Middlewares/ST/AI/Npu/Devices/STM32N6xx/: mcu_cache.c npu_cache.c
    ../Core/Src/: misc_toolbox.c
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/aps256xx/: aps256xx.c
    ../../Drivers/BSP/Components/mx25um51245g/: mx25um51245g.c
    ../../Drivers/BSP/Components/mx66uw1g45g/: mx66uw1g45g.c
  group Drivers/BSP/DK
    ../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_xspi.c
  group Drivers/BSP/Nucleo
    ../../Drivers/BSP/STM32N6xx_Nucleo/: stm32n6xx_nucleo.c stm32n6xx_nucleo_bus.c stm32n6xx_nucleo_xspi.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/iar/: startup_stm32n657xx_fsbl.s
    ../../Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_pcd.c stm32n6xx_hal_pcd_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_uart.c stm32n6xx_hal_xspi.c stm32n6xx_ll_usb.c
  group Middlewares/USBX/Core
    ../../../../../Middlewares/ST/usbx/common/core/src/: ux_system_error_handler.c ux_system_initialize.c ux_system_tasks_run.c ux_system_uninitialize.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_free_block_best_get.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_timer_create.c ux_utility_timer_delete.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group Middlewares/USBX/Device-Core-Stack
    ../../../../../Middlewares/ST/usbx/common/core/src/: ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_tasks_run.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_transfer_run.c ux_device_stack_uninitialize.c
  group Middlewares/USBX/UX-Device-Class-CDC-ACM
    ../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_cdc_acm_activate.c ux_device_class_cdc_acm_bulkin_thread.c ux_device_class_cdc_acm_bulkout_thread.c ux_device_class_cdc_acm_control_request.c ux_device_class_cdc_acm_deactivate.c ux_device_class_cdc_acm_entry.c ux_device_class_cdc_acm_initialize.c ux_device_class_cdc_acm_ioctl.c ux_device_class_cdc_acm_read.c ux_device_class_cdc_acm_read_run.c ux_device_class_cdc_acm_tasks_run.c ux_device_class_cdc_acm_unitialize.c ux_device_class_cdc_acm_write.c ux_device_class_cdc_acm_write_run.c ux_device_class_cdc_acm_write_with_callback.c
  group Middlewares/USBX/UX-Device-Controllers
    ../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_transfer_run.c ux_dcd_stm32_uninitialize.c
  group X-CUBE-AI/App
    ../../../../../Middlewares/ST/AI/Misc/Src/: ai_device_adaptor.c aiTestHelper.c aiTestUtility.c lc_print.c
    ../../../../../Middlewares/ST/AI/Validation/Src/: aiPbIO.c aiPbMemRWServices.c aiPbMgr.c pb_common.c pb_decode.c pb_encode.c stm32msg.pb.c
    ../X-CUBE-AI/App/: network.c stai_network.c
    N6-DK - RELOC/Exe/: Project.out
  group X-CUBE-AI/atonn
    ../../../../../Middlewares/ST/AI/Validation/Src/: ai_io_buffers_ATON.c ai_wrapper_ATON.c ai_wrapper_ATON_ST_AI.c aiValidation_ATON.c aiValidation_ATON_ST_AI.c
  group X-CUBE-AI/atonn/runtime
    ../../../../../Middlewares/ST/AI/Npu/ll_aton/: ecloader.c ll_aton.c ll_aton_cipher.c ll_aton_dbgtrc.c ll_aton_debug.c ll_aton_lib.c ll_aton_lib_sw_operators.c ll_aton_reloc_callbacks.c ll_aton_reloc_network.c ll_aton_rt_main.c ll_aton_runtime.c ll_aton_stai_internal.c ll_aton_util.c ll_sw_float.c ll_sw_integer.c
